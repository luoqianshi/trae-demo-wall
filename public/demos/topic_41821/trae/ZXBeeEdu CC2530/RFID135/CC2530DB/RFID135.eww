<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RFID135.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
    </batchDefinition>
  </batchBuild>
</workspace>


